# Keil uVision project NXP1700_Demo.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1764 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IRAM(0x10000000,0x4000) IRAM2(0x2007C000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NXP1700_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Lib\include;.\User;.\Core;.\Sys
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x10000000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x4000
  group Core
    ./Core/: core_cm3.c core_cm3.h core_cmFunc.h core_cmInstr.h
  group Startup
    ./User/: startup_LPC17xx.s
  group Config
    ./User/: LPC17xx.h lpc17xx_libcfg.h
  group Lib
    ./Lib/source/: lpc17xx_libcfg_default.c debug_frmwrk.c lpc17xx_clkpwr.c lpc17xx_systick.c lpc17xx_uart.c lpc17xx_pinsel.c lpc17xx_gpio.c lpc17xx_timer.c lpc17xx_gpdma.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_wdt.c
  group Sys
    ./Sys/: uart.c uart.h delay.c delay.h time.c time.h gpio.c gpio.h
  group User
    ./User/: main.c system_LPC17xx.c system_LPC17xx.h LPC17xx_it.c LPC17xx_it.h
  group ReadME
    ./ReadME/: ReadMe.txt
